# Keil uVision project FreeRTOS_Demo.uvprojx, settings and files
target MM32 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MM32F103RCT MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Device\MM32F103xCxE_o\HAL_lib\inc;..\Device\MM32F103xCxE_o\Include;..\Device\CMSIS\KEIL_CORE;..\Libraries\FreeRTOS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c
  group STARTUP
    ../Device/MM32F103xCxE_o/Source/: system_MM32F103xCxE_o.c
    ../Device/MM32F103xCxE_o/Source/KEIL_StartAsm/: startup_MM32F103xCxE_o.s
  group HALllib
    ../Device/MM32F103xCxE_o/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group FreeRTOS
    ../Libraries/FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c tasks.c timers.c
